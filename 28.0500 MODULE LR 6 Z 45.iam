# Autodesk Inventor assembly: 28.0500
## iProperties
Created: 2013-02
Part Number: 28.0500
Document SubType Name: Assembly
Designer: Administrator
Description: MODULE LR 6 Z 45
Author: Administrator
